# Keil uVision project test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER_code/Tower/bjdj;..\USER_code\Tower\lll;../USER_code/Tower/Screen;..\USER_code\Tower\vision;../USER_code/Tower/Servo;../USER_code/pid;../USER_code/.git;../USER_code/application;../USER_code/boards;../USER_code/delay_us;../USER_code/chassis;..\MDK-ARM;..\USER_code\DM_Tower\dmdj;..\USER_code\DM_Tower\djdj;..\USER_code\Tower\Tower_test;..\USER_code\DM_Tower\djdj
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group CHASSIS
    ../USER_code/application/: CAN_receive.c CAN_receive.h struct_typedef.h
    ../USER_code/boards/: bsp_can.c bsp_can.h
    ../USER_code/chassis/: A_star.c A_star.h imu.c imu.h navigation.c navigation.h odometer.c odometer.h ring_buffer.c ring_buffer.h speed_planner.c speed_planner.h M3508.c M3508.h chassis_task.c chassis_task.h task_vision_down.c task_vision_down.h
    ../USER_code/pid/: pid.c pid.h
  group TOEWR
    ../USER_code/Tower/bjdj/: Emm_V5.c Emm_V5.h
    ../USER_code/Tower/Screen/: tjc_usart_hmi.c tjc_usart_hmi.h
    ../USER_code/Tower/Servo/: gimbal_solver.c gimbal_solver.h servo.c servo.h
    ../USER_code/Tower/vision/: vision_data_.c vision_data_.h task_vision_up.c task_vision_up.h
    ../USER_code/Tower/lll/: task_tower.c task_tower.h
    ./: lcd_.c lcd_.h cfont_.h mytime_.c mytime_.h system_.h
    ../USER_code/Tower/Tower_test/: tower_test.c tower_test.h
    ../USER_code/DM_Tower/dmdj/: bsp_can_dm.c bsp_can_dm.h DM_task.c DM_task.h J4340.c J4340.h
    ../USER_code/DM_Tower/djdj/: dm_tower_test.c dm_tower_test.h
software components: CMSIS:CORE 4.3.0
